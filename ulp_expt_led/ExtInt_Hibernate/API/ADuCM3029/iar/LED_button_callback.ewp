# IAR project LED_button_callback.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM3029 AnalogDevices ADUCM3029
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ADI_DEBUG
  ICCARM.CCIncludePath2: ../../../../../inc; ../../../../../inc/config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: temperature_sensor.srec
  ILINK.IlinkOutputFile: LED_button_callback.out
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: LED_button_callback.srec
  ILINK.IlinkOutputFile: led_button_callback.out
  group (top)
    $AD3029_BSP_DIR$/examples/gpio/LED_button_callback/: Readme_LED_button_callback.html
  group Driver
    $AD3029_BSP_DIR$/src/services/gpio/: adi_gpio.c
  group Source
    $AD3029_BSP_DIR$/examples/gpio/LED_button_callback/: ExtInt_hib.c
  group System
    $AD3029_BSP_DIR$/src/services/pwr/: adi_pwr.c
    $AD3029_BSP_DIR$/src/drivers/uart/: adi_uart.c
    $AD3029_BSP_DIR$/src/services/wdt/: adi_wdt.c
    $AD3029_BSP_DIR$/src/: common.c startup.c system.c
