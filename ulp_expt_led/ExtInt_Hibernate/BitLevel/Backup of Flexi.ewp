# IAR project Backup of Flexi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM3025 AnalogDevices ADUCM3025
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: C:\Users\RJayaram\Desktop\flexi current measurement\include; C:\Users\RJayaram\Desktop\flexi current measurement\include\Peripherals
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Flexi.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\Users\RJayaram\Desktop\flexi current measurement\ADuCM3025.icf
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main_prime.c pm.c startup.c system.c
