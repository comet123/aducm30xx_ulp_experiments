# IAR project Flexi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM3029 AnalogDevices ADUCM3029
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: C:\Analog Devices\ADuCM302x\ADuCM302x_EZ_Kit_Lite\examples\flexi current measurement\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Flexi.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main_hibernate.c pm.c startup.c system.c
