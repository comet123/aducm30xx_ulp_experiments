# IAR project rtc_alarm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM3029 AnalogDevices ADUCM3029
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ADI_DEBUG
  ICCARM.CCIncludePath2: ../../../../../inc; ../../../../../inc/config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: rtc_alarm.out
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    $AD3029_BSP_DIR$/examples/rtc/Rtc_alarm/: Readme_rtc_alarm.html
  group Driver
    $AD3029_BSP_DIR$/src/services/gpio/: adi_gpio.c
    $AD3029_BSP_DIR$/src/services/rtc/: adi_rtc.c
  group Source
    $AD3029_BSP_DIR$/examples/rtc/Rtc_alarm/: RTC_LEDBlink.c
  group System
    $AD3029_BSP_DIR$/src/services/pwr/: adi_pwr.c
    $AD3029_BSP_DIR$/src/drivers/uart/: adi_uart.c
    $AD3029_BSP_DIR$/src/services/wdt/: adi_wdt.c
    $AD3029_BSP_DIR$/src/: common.c startup.c system.c
